# IAR project HelloWorld.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1x Milandr 1986BE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: SPL\CMSIS\CM3\CoreSupport; SPL\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc; SPL\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\iar; SPL\MDR32F9Qx_StdPeriph_Driver\inc; SPL\MDR32F9Qx_StdPeriph_Driver\src; $PROJ_DIR$; SPL; FreeRTOS; FreeRTOS\include; FreeRTOS\portable\MemMang
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HelloWorld.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Milandr\MDR1986VE9x\MDR32F1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: MDR32F9Qx_board.h
  group Driver
    SPL/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_dac.c MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c
  group FreeRTOS
    FreeRTOS/: croutine.c event_groups.c FreeRTOSConfig.h list.c port.c portasm.s portmacro.h queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/heap
    FreeRTOS/portable/MemMang/: heap_2.c
  group FreeRTOS/include
    FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group src
    ./: main.c
  group Startup
    SPL/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/iar/: startup_MDR32F9Qx.s system_MDR32F9Qx.c system_MDR32F9Qx.h
